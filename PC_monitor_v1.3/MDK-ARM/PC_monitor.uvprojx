# Keil uVision project PC_monitor.uvprojx, settings and files
target PC_monitor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: PC_monitor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../User_code/bsp;../User_code/bsp/key;../User_code/bsp/uart;../User_code/bsp/led;../User_code/bsp/OLED;../User_code/bsp/timer;../User_code/bsp/flash;../User_code/bsp/beep;../User_code/USB;../User_code/Freertos/config;../User_code/Freertos/include;../User_code/Freertos/portable/RVDS/ARM_CM3;../User_code/RTOS_tasks;../User_code/GUI;../User_code/bsp/SHT30
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group bsp
    ../User_code/bsp/beep/: beep.c beep.h music.c music.h
    ../User_code/bsp/flash/: bsp_W25Q.c bsp_W25Q.h
    ../User_code/bsp/key/: bsp_key.c bsp_key.h
    ../User_code/bsp/led/: bsp_led.c bsp_led.h
    ../User_code/bsp/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
    ../User_code/bsp/timer/: bsp_timer.c bsp_timer.h
    ../User_code/bsp/uart/: bsp_uart.c bsp_uart.h
    ../User_code/bsp/: bsp_headfiles.h
    ../User_code/bsp/SHT30/: bsp_sht30.c bsp_sht30.h
  group freertos
    ../User_code/Freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../User_code/Freertos/config/: FreeRTOSConfig.h
    ../User_code/Freertos/portable/MemMang/: heap_4.c
    ../User_code/Freertos/portable/RVDS/ARM_CM3/: port.c
  group freertos/usercode
    ../User_code/Freertos/user_code/: freertos_hooks.c freertos_runtime_stats.c
  group freertos/rtos_tasks
    ../User_code/RTOS_tasks/: basic_task.c basic_task.h start_task.c start_task.h task_manager.c task_manager.h ui_task.c ui_task.h usb_task.c usb_task.h
  group GUI
    ../User_code/GUI/: ui_common.c ui_common.h ui_data.h ui_page_cpu.c ui_page_cpu.h ui_page_gpu.c ui_page_gpu.h ui_page_rtc.c ui_page_rtc.h
  group USB
    ../User_code/USB/: usb_protocol.c usb_protocol.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
